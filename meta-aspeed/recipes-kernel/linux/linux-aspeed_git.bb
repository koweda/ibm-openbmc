KBRANCH ?= "dev-5.4-1"
LINUX_VERSION ?= "5.4.119"

SRCREV="bdee55dfa212761050000c46dc715e50b3bbaa90"

require linux-aspeed.inc
